# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: audio_player.c gallery.c games.c image_filter.c main.c media_center.c audio_player.h gallery.h games.h image_filter.h media_center.h audio_engine.h audio_engine.c adcuser.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c adcuser.h usbcore.h usbdesc.h usbhw.h usbuser.h usbreg.h pixel_ui.h
    U:/coe718/project/examples/LCD_Blinky/: GLCD_SPI_LPC1700.c Font_6x8_h.h Font_16x24_h.h GLCD.h
    U:/coe718/project/examples/USBAudio/: audio.h
  group New Group
    ./: Jensen.c mort.c G_khan.c wojack1.c wojack2.c wojack3.c wojack4.c wojack5.c wojack6.c wojack7.c wojack8.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Board Support:A/D Converter 1.0.0, Board Support:Joystick 1.0.0, Board Support:LED 1.0.0, USB:CORE 6.14.1, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
